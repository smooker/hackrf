options:
  parameters:
    author: SCteam (smooker/LZ1CCM)
    comment: HackRF RX — FFT + Waterfall + Time Scope
    copyright: 2026 SCteam
    description: CW signal analyzer for HackRF One
    generate_options: qt_gui
    id: hackrf_rx_scope
    output_language: python
    title: HackRF RX Scope
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Frequency (MHz)
    start: '1'
    step: '0.1'
    stop: '6000'
    value: '180'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: RF Gain (LNA)
    min_len: '100'
    rangeType: int
    start: '0'
    step: '8'
    stop: '40'
    value: '0'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: IF Gain (VGA)
    min_len: '100'
    rangeType: int
    start: '0'
    step: '2'
    stop: '62'
    value: '20'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: if_gain
    freq0: freq * 1e6
    gain0: rf_gain
    sample_rate: samp_rate
    sync: ''
    type: fc32
  states: {}
- name: qtgui_freq_sink_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: freq * 1e6
    fftsize: '4096'
    grid: 'True'
    gui_hint: 1,0,1,4
    name: '"FFT"'
    type: complex
    update_time: '0.05'
    ymax: '0'
    ymin: '-100'
  states: {}
- name: qtgui_waterfall_sink_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq * 1e6
    fftsize: '4096'
    grid: 'True'
    gui_hint: 2,0,1,4
    int_max: '0'
    int_min: '-100'
    name: '"Waterfall"'
    type: complex
    update_time: '0.05'
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_freq_sink_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.0.0
